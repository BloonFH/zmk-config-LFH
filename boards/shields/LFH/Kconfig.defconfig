## boards/shields/LFH/Kconfig.defconfig
```kconfig
# Copyright (c) 2020 The ZMK Contributors
# SPDX-License-Identifier: MIT

if SHIELD_LFH

config ZMK_KEYBOARD_NAME
    default "lfh"

endif
```
